#
# -*- coding: utf-8; tab-width: 4; c-basic-offset: 4; indent-tabs-mode: nil -*-

AUTHOR = "Thomas Perrot <thomas.perrot@tupi.fr>"

LINUX_VERSION = "4.9.16"

KBRANCH = "linux-4.9.y"

SRCREV = "8a16224b405492bb0ebf450d9f3761580ebe1761"

require recipes-kernel/linux/linux-stable.inc
