#
# -*- coding: utf-8; tab-width: 4; c-basic-offset: 4; indent-tabs-mode: nil -*-

AUTHOR = "Thomas Perrot <thomas.perrot@tupi.fr>"

LINUX_VERSION = "4.7.6"

KBRANCH = "linux-4.7.y"

SRCREV = "f849d45b3247ff5fdb5bee25e120559ea5970d2d"

require recipes-kernel/linux/linux-stable.inc
