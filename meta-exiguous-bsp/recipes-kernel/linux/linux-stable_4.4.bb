#
# -*- coding: utf-8; tab-width: 4; c-basic-offset: 4; indent-tabs-mode: nil -*-

AUTHOR = "Thomas Perrot <thomas.perrot@tupi.fr>"

LINUX_VERSION = "4.4.23"

KBRANCH = "linux-4.4.y"

SRCREV = "d19e48fe5da7b83d02ed4aec3567f08ae02a168c"

require recipes-kernel/linux/linux-stable.inc
