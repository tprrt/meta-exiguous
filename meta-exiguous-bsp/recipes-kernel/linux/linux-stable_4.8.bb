#
# -*- coding: utf-8; tab-width: 4; c-basic-offset: 4; indent-tabs-mode: nil -*-

AUTHOR = "Thomas Perrot <thomas.perrot@tupi.fr>"

LINUX_VERSION = "4.8.12"

KBRANCH = "linux-4.8.y"

SRCREV = "356ccf6d2b0cfe9dca6c5d961bfd04dc8c0f4e64"

require recipes-kernel/linux/linux-stable.inc
