COMPATIBLE_MACHINE_tupi-desktop = "tupi-desktop"
DEFAULT_PREFERENCE_tupi-desktop = "1"

COMPATIBLE_MACHINE_tupi-nas = "tupi-nas"
DEFAULT_PREFERENCE_tupi-nas = "1"

COMPATIBLE_MACHINE_tupi-router = "tupi-router"
DEFAULT_PREFERENCE_tupi-router = "1"

COMPATIBLE_MACHINE_tupi-x220 = "tupi-x220"
DEFAULT_PREFERENCE_tupi-x220 = "1"
