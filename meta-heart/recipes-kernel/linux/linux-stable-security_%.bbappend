#
# -*- coding: utf-8; tab-width: 4; c-basic-offset: 4; indent-tabs-mode: nil -*-

COMPATIBLE_MACHINE_heart = "heart-rpi"
DEFAULT_PREFERENCE_heart-rpi = "1"
