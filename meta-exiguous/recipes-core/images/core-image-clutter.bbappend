inherit exiguous-image
