COMPATIBLE_MACHINE_qemu-exiguous = "qemu-exiguous"
