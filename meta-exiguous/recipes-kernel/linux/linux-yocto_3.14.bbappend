FILESEXTRAPATHS_prepend := "${THISDIR}/linux-yocto_3.14:"
SRC_URI += "file://fix_defconfig_warnings.cfg"
